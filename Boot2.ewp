# IAR project Boot2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2129 NXP LPC2129
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MedRadioPM.hex
  ILINK.IlinkOutputFile: MedRadioPM.out
  ILINK.IlinkIcfFile: Boot2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: Boot2r.hex
  ILINK.IlinkOutputFile: Boot2.out
  ILINK.IlinkIcfFile: C:\Documents and Settings\Jay Hardway\My Documents\projects\Jdcc\nnps\PowerModule\nxpBoot\nxpBoot-0001\trunk\Boot2.icf
  group (top)
    ./: cstartup.s main.c MedRadioBoot2.c MRcc1101radio.c
